IMAGE_INSTALL:append = " wifi-config python-cv bmp280ada ahtx0ada blinkaada platdetectada pureio busdeviceada"
